# Keil uVision project LAB_TIMER_ICAP.uvprojx, settings and files
target Target 1 (6220000::V6.22::ARMCLANG)
  device: STM32F411RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: LAB_TIMER_ICAP +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 wLevel=2
  c include: ..\..\lib
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Source Group 1
    ./: LAB_TIMER_ICAP.c
  group HAL
    ../../lib/: ecEXTI2.c ecEXTI2.h ecGPIO2.c ecGPIO2.h ecICAP2.c ecICAP2.h ecPinNames.c ecPinNames.h ecPWM2.c ecPWM2.h ecRCC2.c ecRCC2.h ecSysTick2.c ecSysTick2.h ecTIM2.c ecTIM2.h ecUART2_simple.c ecUART2_simple.h ecSTM32F4v2.h
software components: CMSIS:CORE 6.1.0, Device:Startup 2.6.3
